# IAR project gpio_k60_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: src\projects; src\projects\gpio; src\common; src\cpu; src\cpu\headers; src\drivers\lptmr; src\drivers\uart; src\drivers\mcg; src\drivers\wdog; src\platforms; IAR\; IAR; src\uCOS-II\App; src\uCOS-II\Source; src\uCOS-II\App\CFG; src\uCOS-II\Ports\; src\CMSIS\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: gpio_k60_tower.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: IAR\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_64KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCIncludePath2: ..\..\..\src\projects\gpio; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Ram.icf
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCIncludePath2: ..\..\..\src\projects\gpio; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\32KB_Ram.icf
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: src\projects; src\projects\gpio; src\common; src\cpu; src\cpu\headers; src\drivers\lptmr; src\drivers\uart; src\drivers\mcg; src\drivers\wdog; src\platforms; IAR\; IAR; ..\; src\uCOS-II\App; src\uCOS-II\Source; src\uCOS-II\App\CFG; src\uCOS-II\Ports; src\LIB\CMSIS
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: IAR\512KB_Pflash.icf
configuration FLASH_256KB_PFLASH_256KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash_256KB_Dflash.icf
configuration FLASH_256KB_PFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
configuration FLASH_128KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_128KB_Dflash.icf
configuration FLASH_128KB_PFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB_PFLASH_64KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: gpio_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash_64KB_Dflash.icf
  group cmsis
    src/CMSIS/: iar_cortexM4l_math.a
  group common
    src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    src/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    src/cpu/headers/: MK60DZ10.h
  group drivers/mcg
    src/drivers/mcg/: mcg.c mcg.h
  group drivers/uart
    src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    src/drivers/wdog/: wdog.c wdog.h
  group IAR
    IAR/: 128KB_Ram.icf 512KB_Pflash.icf iar.h
  group platforms
    src/platforms/: k60_tower.h
  group project
    src/projects/: bsp.c character.c dds_data.c fpga_data.c isr.c main.c mcu_math.c task_common.c
  group uCOS-II/App
    src/uCOS-II/App/: app.c app_hooks.c
  group uCOS-II/App/CFG
    src/uCOS-II/App/CFG/: app_cfg.h os_cfg.h
  group uCOS-II/Ports
    src/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
